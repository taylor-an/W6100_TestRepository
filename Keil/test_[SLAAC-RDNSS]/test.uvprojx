# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\test_[SLAAC-RDNSS];..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\io6Library\Application\loopback;..\..\Libraries\io6Library\Ethernet;..\..\Libraries\io6Library\Ethernet\W6100;..\..\Libraries\io6Library\Internet\DHCP;..\..\Libraries\io6Library\Internet\DNS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\io6Library\Internet\DHCP6
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Apps
    ../../Libraries/io6Library/Application/loopback/: loopback.c
  group Socket
    ../../Libraries/io6Library/Ethernet/: wizchip_conf.c socket.c
  group Ethernet
    ../../Libraries/io6Library/Ethernet/W6100/: w6100.c
  group Internet
    ../../Libraries/io6Library/Internet/DHCP6/: dhcpv6.c
  group User
    ./: main.c stm32f4xx_it.c AddressAutoConfig.c halConfiguration.c usart.c W6100RelFuntioncs.c
